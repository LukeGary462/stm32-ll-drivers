# Keil uVision project Project.uvprojx, settings and files
target STM32446E_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32446E_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/STM32446E_EVAL;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_io.c stm32446e_eval.c stm32446e_eval_sd.c stm32446e_eval_sdram.c stm32446e_eval_lcd.c stm32446e_eval_camera.c
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jdatadst.c jdcolor.c jquant2.c jcparam.c jcapimin.c jaricom.c jdmerge.c jfdctfst.c jdmarker.c jquant1.c jerror.c jdpostct.c jdmaster.c jcapistd.c jidctflt.c jutils.c jccolor.c jdsample.c jcprepct.c jdmainct.c jmemnobs.c jcmarker.c jidctfst.c jctrans.c jdarith.c jddctmgr.c jdhuff.c jdtrans.c jfdctflt.c jidctint.c jcsample.c jdcoefct.c jcmainct.c jdapistd.c jcmaster.c jdinput.c jdatasrc.c jcdctmgr.c jchuff.c jcinit.c jdapimin.c jcomapi.c jcarith.c jmemmgr.c jfdctint.c jccoefct.c
  group Docs
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_usart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sd.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal.c stm32f4xx_hal_i2s.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_flash.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sdram.c
  group Application/User
    ../Src/: stm32f4xx_it.c decode.c jdata_conf.c main.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
