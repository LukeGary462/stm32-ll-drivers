# Keil uVision project Project.uvprojx, settings and files
target STM32446E-EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32446E-EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32446E_EVAL,USE_USB_FS,STM32F446xx,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Core\inc;..\Config;..\Modules\vncserver;..\..\..\..\Utilities\CPU;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32446E_EVAL;..\..\..\..\Drivers\BSP\Components;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM32446E-EVAL\STM32446E-EVAL.sct
  link misc: --diag_suppress=L6329
  group Application/User/Modules/System
    ../Modules/system/: system_win.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_sdram.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_eth.c stm32f4xx_hal_sai.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_can.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_nor.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rng.c stm32f4xx_hal_sd.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_crc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_usart.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dac.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_cec.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_hash.c stm32f4xx_hal_irda.c stm32f4xx_hal_sram.c
  group Application/User/Modules/Camera
    ../Modules/camera/: camera_app.c camera_win.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_ts.c stm32446e_eval_io.c stm32446e_eval.c stm32446e_eval_qspi.c stm32446e_eval_lcd.c stm32446e_eval_camera.c stm32446e_eval_sd.c stm32446e_eval_audio.c stm32446e_eval_sdram.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Modules/Game
    ../Modules/game/: game_win.c
  group Middlewares/STemWin/Config
    ../Config/: LCDConf.c GUIConf.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_OS_Keil.lib
  group Application/User/Modules/USBDevice
    ../Modules/usbdevice/: usbd_storage.c usbd_app.c usbd_desc.c usbd_win.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Application/User/Modules/AudioPlayer
    ../Modules/audioplayer/: audioplayer_app.c audioplayer_win.c
  group Middlewares/USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/User/Core
    ../Core/Src/: k_sd_diskio.c k_modules_res.c k_rtc.c k_storage.c stm32f4xx_it.c k_bsp.c k_menu.c k_module.c k_mem.c k_startup.c k_calibration.c k_log.c main.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c queue.c croutine.c list.c
  group Middlewares/USBH_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_data.c usbd_msc_scsi.c usbd_msc.c usbd_msc_bot.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User/Modules/Benchmark
    ../Modules/benchmark/: benchmark_win.c
  group Application/User/Modules/FileBrowser
    ../Modules/filebrowser/: filebrowser_win.c filebrowser_app.c
  group Application/User/Modules/ImageBrowser
    ../Modules/imagebrowser/: imagebrowser_win.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/ST/STM32_Audio/Addons/PDM
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_Keil.lib
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 3.40.0
