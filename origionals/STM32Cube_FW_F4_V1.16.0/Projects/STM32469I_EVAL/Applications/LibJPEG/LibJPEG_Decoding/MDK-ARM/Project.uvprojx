# Keil uVision project Project.uvprojx, settings and files
target STM32469I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.1
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32469I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/STM32469I_EVAL;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_i2s.c stm32f4xx_ll_fmc.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_dsi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2s_ex.c
  group Application/User
    ../Src/: main.c jdata_conf.c decode.c stm32f4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jidctint.c jcmaster.c jdcoefct.c jcomapi.c jdhuff.c jdinput.c jdapimin.c jcapistd.c jfdctflt.c jdarith.c jcdctmgr.c jchuff.c jcarith.c jcapimin.c jccoefct.c jcsample.c jcinit.c jaricom.c jcmainct.c jddctmgr.c jfdctint.c jdatadst.c jmemmgr.c jdmainct.c jdsample.c jdmerge.c jcparam.c jdmarker.c jdatasrc.c jquant1.c jquant2.c jfdctfst.c jcprepct.c jctrans.c jutils.c jccolor.c jdpostct.c jdmaster.c jerror.c jidctflt.c jdapistd.c jdtrans.c jcmarker.c jdcolor.c jidctfst.c jmemnobs.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_sd.c stm32469i_eval.c stm32469i_eval_lcd.c stm32469i_eval_io.c stm32469i_eval_sdram.c stm32469i_eval_camera.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
