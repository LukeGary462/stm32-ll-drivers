# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324x9I_EVAL;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
  group Application/User
    ../Src/: decode.c stm32f4xx_it.c main.c jdata_conf.c encode.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_sd.c stm324x9i_eval_lcd.c stm324x9i_eval_io.c stm324x9i_eval_sdram.c stm324x9i_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jdmainct.c jerror.c jdmarker.c jdcolor.c jutils.c jdpostct.c jccolor.c jdapistd.c jddctmgr.c jfdctfst.c jdatadst.c jcinit.c jidctint.c jcmaster.c jcsample.c jmemnobs.c jcmarker.c jquant1.c jdmaster.c jcprepct.c jdarith.c jcomapi.c jdsample.c jidctflt.c jquant2.c jchuff.c jidctfst.c jdatasrc.c jdmerge.c jcapimin.c jccoefct.c jdhuff.c jfdctint.c jctrans.c jdtrans.c jdapimin.c jdcoefct.c jfdctflt.c jdinput.c jcdctmgr.c jcmainct.c jcarith.c jmemmgr.c jcparam.c jcapistd.c jaricom.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_smartcard.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sai.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_can.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_usart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_sd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_irda.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_rtc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_nand.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc_ex.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
software components: CMSIS:CORE 4.3.0
