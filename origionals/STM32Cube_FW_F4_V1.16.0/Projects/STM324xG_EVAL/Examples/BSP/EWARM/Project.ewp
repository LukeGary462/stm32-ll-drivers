# IAR project Project.ewp, settings and files
configuration STM324xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM324xG_EVAL; ..\..\..\..\..\Drivers\BSP\Components\ili9325; ..\..\..\..\..\Drivers\BSP\Components\stmpe811; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_eeprom.c stm324xg_eval_io.c stm324xg_eval_lcd.c stm324xg_eval_sd.c stm324xg_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32f407xx.s
  group Example/User
    ../Src/: eeprom.c joystick.c lcd.c log.c main.c sd.c stm32f4xx_it.c touchscreen.c ts_calibration.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
