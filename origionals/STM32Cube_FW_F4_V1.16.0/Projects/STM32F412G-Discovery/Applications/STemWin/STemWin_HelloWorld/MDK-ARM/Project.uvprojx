# Keil uVision project Project.uvprojx, settings and files
target STM32412G_DISCOVERY (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32412G_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/inc;../../../../../../Drivers/BSP/STM32412G-Discovery;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32412G-Discovery
    ../../../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_i2c.c
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm32412g_discovery.c GUIConf_stm32412g_discovery.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ls016b8uy/: ls016b8uy.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Application/User
    ../Src/: stm32f4xx_it.c BASIC_HelloWorld.c main.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_Keil.lib
software components: CMSIS:CORE 4.3.0
