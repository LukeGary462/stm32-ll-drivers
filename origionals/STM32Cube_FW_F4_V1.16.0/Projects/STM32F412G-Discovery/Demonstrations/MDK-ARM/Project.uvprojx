# Keil uVision project Project.uvprojx, settings and files
target STM32412G-Discovery_Demo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32412G-Discovery_Demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F412Zx,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ../STemWin_Addons;../Config;../Core/inc;../../../../Utilities/CPU;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32412G-Discovery;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/ls016b8uy;../../../../Drivers/BSP/Components/ft6x06;../../../../Drivers/BSP/Components/Common;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../Middlewares/ST/STemWin/inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: STM32412G-Discovery_Demo\STM32412G-Discovery_Demo.sct
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32412G-Discovery
    ../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c stm32412g_discovery_sd.c stm32412g_discovery_audio.c stm32412g_discovery_lcd.c stm32412g_discovery_qspi.c stm32412g_discovery_ts.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_scsi.c usbd_msc_data.c usbd_msc.c usbd_msc_bot.c
  group Middlewares/USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Application/User/Modules/Info
    ../Modules/information/: information_win.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_win.c audio_player_app.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
  group Application/User/Modules/Analog_Clock
    ../Modules/analog_clock/: analog_clock_win.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: video_player_win.c GUI_AVI.c
  group Application/User/Modules/USB_Storage
    ../Modules/usb_storage/: usbd_storage.c usbd_desc.c usb_storage_win.c usbd_app.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../Drivers/BSP/Components/ls016b8uy/: ls016b8uy.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Application/User/Core
    ../Core/Src/: k_menu.c k_storage.c main.c k_rtc.c k_module.c k_startup.c k_bsp.c k_calibration.c stm32f4xx_it.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c event_groups.c timers.c queue.c tasks.c croutine.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Drivers/STM32F4_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pccard.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_eth.c stm32f4xx_hal_nor.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_lptim.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cryp.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_irda.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_cec.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_hcd.c stm32f4xx_hal.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sd.c stm32f4xx_hal_hash.c stm32f4xx_hal_smartcard.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_flash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_nand.c stm32f4xx_hal_pcd.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_usb.c
  group Application/User/Modules/audio_recorder
    ../Modules/audio_recorder/: audio_recorder_app.c audio_recorder_win.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_OS_Keil_ot.lib
  group Middlewares/STemWin/ST_GUI_Addons
    ../STemWin_Addons/: STM32F412G_DISCO_STemWin_Addons_Keil.lib
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/PDM
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_Keil.lib
software components: CMSIS:CORE 4.3.0
