# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_rtc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery_sd.c stm32f413h_discovery_lcd.c stm32f413h_discovery.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User
    ../Src/: jdata_conf.c main.c stm32f4xx_it.c encode.c decode.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../../Drivers/BSP/Components/ls016b8uy/: ls016b8uy.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jdinput.c jquant2.c jctrans.c jcmaster.c jfdctfst.c jcapistd.c jcdctmgr.c jcarith.c jcomapi.c jdapimin.c jdcoefct.c jdmerge.c jdatadst.c jdmaster.c jddctmgr.c jdmarker.c jdapistd.c jmemmgr.c jcapimin.c jccoefct.c jdcolor.c jmemnobs.c jcmainct.c jdsample.c jdtrans.c jcparam.c jquant1.c jidctflt.c jfdctflt.c jaricom.c jccolor.c jdhuff.c jfdctint.c jidctfst.c jutils.c jcinit.c jcsample.c jerror.c jcprepct.c jdpostct.c jdatasrc.c jcmarker.c jidctint.c jdmainct.c jchuff.c jdarith.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
