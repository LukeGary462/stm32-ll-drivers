# Keil uVision project Project.uvprojx, settings and files
target STM32F429I_DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I_DISCO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F429I-Discovery;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/inc
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jcsample.c jidctfst.c jcinit.c jdapimin.c jcmaster.c jdcolor.c jdapistd.c jfdctint.c jcapistd.c jddctmgr.c jfdctflt.c jquant2.c jquant1.c jdsample.c jccolor.c jcomapi.c jcmarker.c jdhuff.c jmemnobs.c jcprepct.c jdmainct.c jmemmgr.c jdatasrc.c jdatadst.c jchuff.c jcmainct.c jerror.c jcarith.c jdmarker.c jdinput.c jdarith.c jutils.c jaricom.c jcdctmgr.c jdtrans.c jidctint.c jdpostct.c jdcoefct.c jcapimin.c jdmerge.c jidctflt.c jcparam.c jdmaster.c jfdctfst.c jctrans.c jccoefct.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_pipes.c usbh_ctlreq.c usbh_core.c
  group Drivers/BSP/STM32F429I_DISCO
    ../../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery_sdram.c stm32f429i_discovery_io.c stm32f429i_discovery.c stm32f429i_discovery_lcd.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dac_ex.c stm32f4xx_hal_crc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_eth.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_usart.c stm32f4xx_hal_hash.c stm32f4xx_hal_dac.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_pcd.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_nor.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sai.c stm32f4xx_hal_irda.c stm32f4xx_hal_cryp.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2s_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Application/User
    ../Src/: usbh_conf.c stm32f4xx_it.c jdata_conf.c decode.c main.c
software components: CMSIS:CORE 4.3.0
